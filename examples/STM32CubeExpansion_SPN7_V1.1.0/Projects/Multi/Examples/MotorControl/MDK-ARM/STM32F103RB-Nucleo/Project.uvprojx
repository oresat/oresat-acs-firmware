# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB-Nucleo Configuration (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB-Nucleo Configuration
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc ;..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM07M1;..\..\..\..\..\..\Drivers\BSP\Components\l6230;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F1xx-Nucleo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F1xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group Example/User
    ../../Src/: stm32F103_nucleo_ihm07m1.c stm32f1xx_hal_msp.c main_F103.c stm32f1xx_it.c
    ../../Inc/: MC_SixStep_param.h
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6230/: l6230.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_tim.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c
  group Drivers/Middlewares/MC_6Step_Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Drivers/BSP/X-NUCLEO-IHM07M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM07M1/: X-NUCLEO-IHM07M1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/Middlewares/UART_serial_com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
target STM32F103RB-Nucleo - COMM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: STM32F103RB-Nucleo - COMM
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,UART_COMM
  c misc: --C99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.0

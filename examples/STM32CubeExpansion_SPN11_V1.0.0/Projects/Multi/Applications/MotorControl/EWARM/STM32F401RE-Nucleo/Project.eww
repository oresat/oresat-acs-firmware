<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F401RE-Nucleo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>DEMO1</name>
      <member>
        <project>STM32F401RE-Nucleo</project>
        <configuration>STM32F401RE-Nucleo - Demo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



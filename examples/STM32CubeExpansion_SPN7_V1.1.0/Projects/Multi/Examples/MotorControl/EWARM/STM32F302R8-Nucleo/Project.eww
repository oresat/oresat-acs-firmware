<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F302R8-Nucleo.ewp</path>
  </project>
  <batchBuild />
</workspace>

# IAR project STM32F401RE-Nucleo.ewp, settings and files
configuration STM32F401RE-Nucleo Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\STSPIN230; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM11M1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo-Configuration.bin
  ILINK.IlinkOutputFile: STM32F401RE-Nucleo Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401RE-Nucleo - COMM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; UART_COMM
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM11M1; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\STSPIN230; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo-COMM.bin
  ILINK.IlinkOutputFile: STM32F401RE-Nucleo COMM.out
configuration STM32F401RE-Nucleo - Demo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; DEMOMODE
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo-Demo.bin
  ILINK.IlinkOutputFile: STM32F401RE-Nucleo Demo.out
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/STSPIN230/: STSPIN230.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM11M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM11M1/: X-NUCLEO-IHM11M1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Example/User
    ../../Src/: main_F401.c stm32F401_nucleo_ihm11m1.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../Inc/: MC_SixStep_param.h
  group Middlewares/MC_6Step_Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
